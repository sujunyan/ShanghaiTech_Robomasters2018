# Keil uVision project RMv3testDemo.uvprojx, settings and files
target Infantry (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RMv3testDemo +hex
  AfterMake: fromelf.exe  --bin -o ./bin/test.bin .\RMv3testDemo\RMv3testDemo.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Test\Inc;../rmlib;..\FreeRTOS\Source\include;..\MDK-ARM;.\bsp;..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ./: startup_stm32f427xx.s
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c freertos.c cpu_utils.c
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/include/: FreeRTOSConfig.h
  group CMSIS
    ../Src/: system_stm32f4xx.c
  group Library
    ../rmlib/: pid.c protocol.c ramp.c
  group UserBsp
    ./bsp/: bsp_can.c bsp_can.h bsp_flash.c bsp_flash.h bsp_imu.c bsp_imu.h bsp_uart.c bsp_uart.h
  group Init
    ./: init.c
  group Test
    ../Test/Src/: test_uart.c test_app.c test_beep.c test_usb.c test_imu.c
    ./: test.c test.h detect_task.c detect_task.h
  group main
    ../Src/: usart.c usbd_conf.c spi.c main.c can.c usbd_cdc_if.c gpio.c stm32f4xx_hal_msp.c dma.c usbd_desc.c usb_device.c stm32f4xx_it.c tim.c
    ./: sys_config.h
  group Debug
    ../Test/Src/: Serial_Debug.c
    ../Test/Inc/: Serial_Debug.h
  group RemoteTask
    ../Src/: RemoteTask.c
    ../Inc/: RemoteTask.h
  group ControlTask
    ./: chasis_task.c chasis_task.h
software components: CMSIS:CORE 4.1.0
